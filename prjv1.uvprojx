# Keil uVision project prjv1.uvprojx, settings and files
target Source (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: prjv1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Source\Driver;.\Source\Module;.\Source\Module
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Driver
    ./Source/Driver/: PFPA.c GPIO.c WDT.c Utility.c
  group Module
    ./Source/Module/: KeyScan.c FSM.c RTC.c Segment.c Buzzer.c EEPROM.c
  group UserApp
    ./Source/UserAPP/: main.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
